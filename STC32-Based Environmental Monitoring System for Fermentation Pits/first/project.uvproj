# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: project
  group usr
    ./: main.c main.h
  group sys
    ./: spi.c spi.h ustar.c ustar.h
  group Hardware
    ./: oled.c oled.h dth11.c dth11.h
