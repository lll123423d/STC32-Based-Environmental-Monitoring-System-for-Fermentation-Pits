# Keil uVision project projrct.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: projrct +hex
  group User
    ./User/: main.c main.h
  group Hardware
    ./Hardware/: dth11.c dth11.h fontoled.c fontoled.h oled.c oled.h
  group System
    ./System/: SPI.c SPI.h system.c system.h USTAR1.c USTAR1.h
