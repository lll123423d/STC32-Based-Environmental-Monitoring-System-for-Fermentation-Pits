# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: project +hex
  group usr
    ./Usr/: main.c pic.h stc.h stc32g.h vk.h
  group sys
    ./sys/: SPI.c SPI.h sys.c sys.h
  group Hardware
    ./Hardware/: font.h oled.c oled.h pic.h
    ./: oledconfig.h
