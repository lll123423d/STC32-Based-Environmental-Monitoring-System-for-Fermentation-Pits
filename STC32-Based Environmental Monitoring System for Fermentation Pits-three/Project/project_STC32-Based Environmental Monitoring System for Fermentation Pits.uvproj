# Keil uVision project project_STC32-Based Environmental Monitoring System for Fermentation Pits.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: project_STC32-Based Environmental Monitoring System for Fermentation Pits +hex
  group System
    ../System/: SPI.c SPI.h USTAR1.c system.c USTAR1.h system.h
  group User
    ../User/: main.h main.c
  group Hardware
    ../Hardware/: dth11.c dth11.h oled.c oled.h fontoled.h fontoled.c
